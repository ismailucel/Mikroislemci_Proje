# Keil uVision project g201210352.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: g201210352 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: mikro_2.a51
